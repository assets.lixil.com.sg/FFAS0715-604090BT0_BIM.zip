Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-14T10:37:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 14 10:37:29 2024 * Host: LAPTOP-TVR8NT0T * Database: C:\Users\user\AppData\Local\Temp\cb292adb-013e-46ca-a64c-b5e7d75fd791\8c404f96-64ce-46a2-b1b7-ef7b41b6c935\ifc * Database version: 5507 * Database creation date: Sun Jan 14 10:37:28 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 14 10:37:29 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 14 10:37:29 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: FFAS0715-604090BT0_REVIT:Neo Modern DH Bath Mixer(white)-TH, FFAS0715-604090BT0_REVIT:Neo Modern DH Bath Mixer(white)-TH:33343
In: Level 1
Type - Material: Plastic, Opaque White
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Neo Modern DH Bath Mixer(white)-TH
Pset_DistributionFlowElementCommon - Reference: Neo Modern DH Bath Mixer(white)-TH; sets with these values: 2
